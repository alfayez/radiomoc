<?xml version='1.0' encoding='ASCII'?>
<flow_graph>
  <timestamp>Fri Feb 15 12:05:34 2013</timestamp>
  <block>
    <key>options</key>
    <param>
      <key>id</key>
      <value>new_heir</value>
    </param>
    <param>
      <key>_enabled</key>
      <value>True</value>
    </param>
    <param>
      <key>title</key>
      <value></value>
    </param>
    <param>
      <key>author</key>
      <value></value>
    </param>
    <param>
      <key>description</key>
      <value></value>
    </param>
    <param>
      <key>window_size</key>
      <value>1280, 1024</value>
    </param>
    <param>
      <key>generate_options</key>
      <value>hb</value>
    </param>
    <param>
      <key>category</key>
      <value>Custom</value>
    </param>
    <param>
      <key>run_options</key>
      <value>prompt</value>
    </param>
    <param>
      <key>run</key>
      <value>True</value>
    </param>
    <param>
      <key>max_nouts</key>
      <value>0</value>
    </param>
    <param>
      <key>realtime_scheduling</key>
      <value></value>
    </param>
    <param>
      <key>_coordinate</key>
      <value>(10, 10)</value>
    </param>
    <param>
      <key>_rotation</key>
      <value>0</value>
    </param>
  </block>
  <block>
    <key>digital_dxpsk_mod</key>
    <param>
      <key>id</key>
      <value>dbpskTransmitter</value>
    </param>
    <param>
      <key>_enabled</key>
      <value>True</value>
    </param>
    <param>
      <key>type</key>
      <value>dbpsk</value>
    </param>
    <param>
      <key>samples_per_symbol</key>
      <value>2</value>
    </param>
    <param>
      <key>excess_bw</key>
      <value>0.35</value>
    </param>
    <param>
      <key>gray_coded</key>
      <value>True</value>
    </param>
    <param>
      <key>verbose</key>
      <value>False</value>
    </param>
    <param>
      <key>log</key>
      <value>False</value>
    </param>
    <param>
      <key>_coordinate</key>
      <value>(400, 203)</value>
    </param>
    <param>
      <key>_rotation</key>
      <value>0</value>
    </param>
  </block>
  <block>
    <key>gr_interp_fir_filter_xxx</key>
    <param>
      <key>id</key>
      <value>channelFilter</value>
    </param>
    <param>
      <key>_enabled</key>
      <value>True</value>
    </param>
    <param>
      <key>type</key>
      <value>ccc</value>
    </param>
    <param>
      <key>interp</key>
      <value>samplingRate2/samplingRate</value>
    </param>
    <param>
      <key>taps</key>
      <value>0.00009979730726535182734615592181626198, -0.000100505550765651511082102165239859914, 0.000086241122844543649777343530260509397,-0.000067496456868908080934180149235146473, 0.000038055707197024689618803511281797114, 0.000002308927879570821060380798536715297, -0.000038934888020601433064951657492258619,  0.0000797949012601345720888459944752924, -0.000119271397627435403248838396983444454, 0.000141588780926367869801921206551753585, -0.000159486503090906062791651254251235059, 0.00016278021662664320166717668580957934, -0.000139825098689991776917257437773400852, 0.000111501293582660625388312813921487532, -0.00006400835217915140261044082414798595, -0.000005006490874363215331176689415482173, 0.000065759885101799990005100315926256371, -0.000137653864730918386056340851908430523, 0.000210797987857793675319992288130777069, -0.000250749579031937233023624722605404713, 0.000288557249057667930796505784130090433, -0.000301317569520909763619576082760431746, 0.000259377812119693034690476318715468551, -0.000213724006086556784318394863753098889, 0.000126678781682289232340260509701579394, 0.000013949015769916376684955938713983414, -0.000131217348685418172668168401706623172, 0.00028579933421299808914833873174643486, -0.00045836693707892686060548226301136765, 0.000547710656233076857019037575469155854, -0.000657871130322525859458748787034210181, 0.000719950102798743059306918468109870446, -0.000622716978035946547818946239516435526, 0.000550853545184937579137773866477800766, -0.000350683627360438463730490932235284163, -0.000065340665929834707524592740668367696, 0.000370412330330842950835978921730884394, -0.000891495468632764933442080845793498156, 0.001614087658203858547875664264381612156, -0.001956070124727197177827431318064554944, 0.002664658433291339310194922873620271275, -0.003382225612193875442790247376478873775, 0.002970158926546061749218718972542774281, -0.003425616950978864483357000381147372536, 0.002932504612944049088990583484815033444, 0.001817811091226404591678078581651334389, -0.00323201843756877084390399801350213238, 0.016027413383035659516506754584952432197, -0.096710592066912529074507176574115874246, 0.240354903905041800138420171606412623078, 0.681971863420548829459733042313018813729, 0.240354903905041800138420171606412623078, -0.096710592066912529074507176574115874246, 0.016027413383035659516506754584952432197, -0.00323201843756877084390399801350213238, 0.001817811091226404591678078581651334389, 0.002932504612944049088990583484815033444, -0.003425616950978864483357000381147372536, 0.002970158926546061749218718972542774281, -0.003382225612193875442790247376478873775, 0.002664658433291339310194922873620271275, -0.001956070124727197177827431318064554944, 0.001614087658203858547875664264381612156, -0.000891495468632764933442080845793498156, 0.000370412330330842950835978921730884394, -0.000065340665929834707524592740668367696, -0.000350683627360438463730490932235284163, 0.000550853545184937579137773866477800766, -0.000622716978035946547818946239516435526, 0.000719950102798743059306918468109870446, -0.000657871130322525859458748787034210181, 0.000547710656233076857019037575469155854, -0.00045836693707892686060548226301136765, 0.00028579933421299808914833873174643486, -0.000131217348685418172668168401706623172, 0.000013949015769916376684955938713983414, 0.000126678781682289232340260509701579394, -0.000213724006086556784318394863753098889, 0.000259377812119693034690476318715468551, -0.000301317569520909763619576082760431746, 0.000288557249057667930796505784130090433, -0.000250749579031937233023624722605404713, 0.000210797987857793675319992288130777069, -0.000137653864730918386056340851908430523, 0.000065759885101799990005100315926256371, -0.000005006490874363215331176689415482173, -0.00006400835217915140261044082414798595, 0.000111501293582660625388312813921487532, -0.000139825098689991776917257437773400852, 0.00016278021662664320166717668580957934, -0.000159486503090906062791651254251235059, 0.000141588780926367869801921206551753585,-0.000119271397627435403248838396983444454, 0.0000797949012601345720888459944752924, -0.000038934888020601433064951657492258619, 0.000002308927879570821060380798536715297, 0.000038055707197024689618803511281797114, -0.000067496456868908080934180149235146473, 0.000086241122844543649777343530260509397, -0.000100505550765651511082102165239859914, 0.00009979730726535182734615592181626198</value>
    </param>
    <param>
      <key>_coordinate</key>
      <value>(600, 200)</value>
    </param>
    <param>
      <key>_rotation</key>
      <value>0</value>
    </param>
  </block>
</flow_graph>
