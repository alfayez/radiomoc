<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>OCCAM_generated</value></param>
<param><key>author</key><value>Almohanad Fayez</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbolTime</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carrierFreq</value></param>
<param><key>value</key><value>4.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rcFiltCoeff</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carrierGain</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rfGain</value></param>
<param><key>value</key><value>30.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rfGain2</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carrierPhase</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gaussGain</value></param>
<param><key>value</key><value>0.3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recvThresh</value></param>
<param><key>value</key><value>0.3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seedValG</value></param>
<param><key>value</key><value>0L</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>meanValG</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>stdValG</value></param>
<param><key>value</key><value>0.40</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>rfScale</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0.3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:0</value></param>
<param><key>samp_rate</key><value>samplingRate2</value></param>
<param><key>center_freq0</key><value>462562500</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samplingRate</value></param>
<param><key>value</key><value>320000</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>dbpskEnc</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_symbol</key><value>10</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>access_code</key><value></value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>rfScale_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>10</value></param>
</block>
<block>
<key>digital_dxpsk_mod</key>
<param><key>id</key><value>dbpskMod</value></param>
<param><key>type</key><value>dbpsk</value></param>
<param><key>samples_per_symbol</key><value>samplingRate2/samplingRate</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>gray_coded</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/home/alfayez/workspace/occam-research/music-tx1.0.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samplingRate2</value></param>
<param><key>value</key><value>640000</value></param>
</block>
<connection><source_block_id>dbpskEnc</source_block_id><sink_block_id>dbpskMod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfScale</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dbpskMod</source_block_id><sink_block_id>rfScale</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfScale_0</source_block_id><sink_block_id>dbpskEnc</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>rfScale_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
